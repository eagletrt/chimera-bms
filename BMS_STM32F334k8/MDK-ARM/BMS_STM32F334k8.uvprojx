# Keil uVision project BMS_STM32F334k8.uvprojx, settings and files
target BMS_STM32F334k8 (ARM-ADS)
  device: STM32F334K8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BMS_STM32F334k8
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c include: ../Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
  group Application/User
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_pwr.c stm32f3xx_hal_spi.c stm32f3xx_hal_gpio.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c
software components: CMSIS:CORE 4.3.0
