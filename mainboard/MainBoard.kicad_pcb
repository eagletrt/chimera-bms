# Repository eagletrt/chimera-bms

File README.md:

# Chimera high voltage BMS  - hardware

## Libraries
The projects don't include the libraries since they use the KiCAD official ones.
Set accordingly the variables `${KICAD_SYMBOL_DIR}` and `${KISYSMOD}` for 
`kicad-symbols` and `kicad-footprints` respectively.
**For `kicad-symbols` checkout the repo to `v5` for now to have the legacy ones.**

Don't rescue symbols!

## Repo structure
```
chimera-bms:hw-master
|-- docs/       # Docs and datasheets of common interest
|-- mainboard/  # MainBoard hardware project folder
|-- cellboard/  # CellBoard hardware project folder
```

## KiCad design mainboard/MainBoard.kicad_pcb

File mainboard/README.md:

# MAIN BOARD
Formula SAE - unitn

## Authors
Latest first:
- Filippo Volpe
- Gregor Gombac
- Jesus probably

## Project structure
```
mainboard
|-- MainBoard.pro           # Project file
|-- MainBoard.sch           # Schematic root
|-- MainBoard.kicad_pcb     # Board layout file
|-- MainBoard-cache.lib     # Local cache of symbols
|-- fp-info-cache           # Cache of footprints
|-- fp-lib-table            # List of footprint lib files
|-- sym-lib-table           # List of symbols lib files
|-- lib_sch/                # Local symbol library files
|-- modules/                # Local symbol library files
|   |-- MainBoard.pretty/   # Local footprint library files
|   |-- packages3d/         # 3D models
|-- outputs/
|   |-- MainBoard.stp       # Board 3D step file
|   |-- images/             # Board renders and such
|   |-- gerber/             # Gerbers outputs
|   |-- netlists/           # Netlists outputs
|-- docs/                   # Additional related documents and outputs
|   |-- Decoupling.txt      # List of decoupling capacitor needed
|   |-- bom/                # BOM folder
```

## Notes
The board file is from V2, it has not been updated

Parts:
C1: 47u; C_1206_3216Metric
C2, C12: 4.7u; C_0805_2012Metric
C3, C4, C7, C8, C11, C14, C15, C17, C18, C22, C24, C35: 100n; C_0603_1608Metric
C5, C21: 1u; C_0805_2012Metric
C16: 10u; C_0805_2012Metric
C20: 4.7n; C_0603_1608Metric
F2, F3: 0ZCG 2A; Fuse_1812_4532Metric
J1: isoSPI; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J2: SWD; PinHeader_2x05_P2.54mm_Vertical
J3: IMD; PinHeader_1x08_P3mm_Vertical
J4: IO; Molex_Micro-Fit_3.0_43045-1612_2x08_P3.00mm_Vertical
J7: BYPASS_IMD; PinHeader_1x02_P2.54mm_Vertical
J11: ON_HANDCART; PinHeader_1x02_P2.54mm_Vertical
J13: SWD_old; PinHeader_1x06_P2.54mm_Vertical
R1: 604; R_0805_2012Metric
R2: 3.4k; R_0805_2012Metric
R3, R5: 22; R_0805_2012Metric
R4, R8: 120; R_0805_2012Metric
R6, R7, R10, R22: 10k; R_0805_2012Metric
R9: 22k; R_0805_2012Metric
R51: 1k; R_0805_2012Metric
SW1: RESET; SW_SPST_FSMSM
SW2: SD_RESET; SW_SPST_FSMSM
U1: LTC6820; MSOP-16
U2: HM2103
U5: STM32F334K8; LQFP-32_7x7mm_P0.8mm
U6: MicroSD; Molex_MicroSD_PushPull
U7: MCP2562; SOIC-8_3.9x4.9mm_P1.27mm
U8: LM1117-3.3; SOT-223-3_TabPin2
U9: HTFS200-P; HTFS 200-P
U10: REF2920; SOT-23

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C11.1, C15.1, C16.1, J2.7, J13.2, R51.2, U1.6 (VDDs), U5.1 (VDD), U5.5 (VDDA), U5.17 (VDD), U6.4 (VDD), U7.5 (VIO), U8.2 (VO); also elsewhere on the board
+5V: C12.1, C14.1, C17.1, C18.1, C21.1, F3.1, J2.8, J13.1, U1.9 (VDD), U1.12 (MSTR), U7.3 (VDD), U8.3 (VI), U9.1 (V+), U10.1 (IN); also elsewhere on the board
+12V: F2.2, J3.2, J7.2; also elsewhere on the board
/6820: U1.5 (~CS), U5.15 (PB1)
/ADC_RX: U5.29 (PB6); also elsewhere on the board
/ADC_TX: U5.30 (PB7); also elsewhere on the board
/BMS_Fault: U5.20 (PA10); also elsewhere on the board
/CAN+: J4.6, R8.2, U7.7 (CANH)
/CAN-: J4.13, R8.1, U7.6 (CANL)
/CANS: J4.5, U5.18 (PA8)
/CD: U5.11 (PA5), U6.9 (CD)
/Current: C20.1, R6.1, U9.3 (OUT)
/HANDCART: J11.1, U5.2 (PF0)
/I+: U1.11 (IP), U2.4
/I-: U1.10 (IM), U2.6
/IBIAS: R1.2, U1.16 (IBIAS)
/ICMP: R1.1, R2.2, U1.15 (ICMP)
/IMD: R10.1, R22.2, U5.25 (PA15)
/IMD_Fault: J3.8, J7.1; also elsewhere on the board
/MISO: R51.1, U1.3 (MISO), U5.27 (PB4), U6.7 (SDO)
/MOSI: U1.2 (MOSI), U5.28 (PB5), U6.3 (SDI)
/PC_Ended: U5.7 (PA1); also elsewhere on the board
/RST: C24.1, J2.4, J13.5, SW1.2, U5.4 (~RESET)
/RST_ADCB: U5.13 (PA7); also elsewhere on the board
/RX: J2.10, U5.9 (PA3)
/SCK: U1.4 (SCK), U5.26 (PB3), U6.5 (SCK)
/SDCard: U5.10 (PA4), U6.2 (~CS)
/SD_Status: U5.12 (PA6); also elsewhere on the board
/SWCLK: J2.3, J13.4, U5.24 (PA14)
/SWDIO: J2.5, J13.3, U5.23 (PA13)
/TS_ON: U5.19 (PA9); also elsewhere on the board
/TX: J2.9, U5.8 (PA2)
/WC: U5.14 (PB0)
/isoSPI+: J1.1, R3.1, R4.2
/isoSPI-: J1.2, R4.1, R5.1
BMS_LED: J4.1; also elsewhere on the board
From_SD: J4.11; also elsewhere on the board
From_TSMS: J4.7; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C11.2, C12.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C24.2, C35.2, J2.1, J2.2, J3.1, J3.3, J3.4, J4.14, J4.15, J11.2, J13.6, R2.1, R7.1, R10.2, SW1.1, SW2.1, U1.1 (EN), U1.7 (POL), U1.8 (PHA), U1.13 (SLOW), U1.14 (GND), U5.16 (VSS), U5.31 (BOOT0), U5.32 (VSS), U6.6 (VSS), U6.10 (CD), U7.2 (VSS), U7.8 (STBY), U8.1 (GND), U9.2 (GND), U10.3 (GND); also elsewhere on the board
IMD_LED: J4.9; also elsewhere on the board
INV_Enable: J4.3; also elsewhere on the board
NRelayStat: J4.16; also elsewhere on the board
unnamed: C22.1, U9.4 (Vref), U10.2 (OUT)
unnamed: F2.1, J4.4
unnamed: F3.2, J4.12
unnamed: J3.5, R9.1
unnamed: R3.2, U2.3
unnamed: R5.2, U2.1
unnamed: R6.2, R7.2, U5.6 (PA0)
unnamed: R9.2, R22.1
unnamed: U5.21 (PA11), U7.4 (RXD)
unnamed: U5.22 (PA12), U7.1 (TXD)
RESET_BUTTON: C35.1, J4.10, SW2.2; also elsewhere on the board
RelayStat: J4.8; also elsewhere on the board
To_TSMS: J4.2; also elsewhere on the board

Notes on the sheet:
MEMORY
isoSPI INTERFACE
CAN INTERFACE
3.3V VOLTAGE REGULATOR
SWD INTERFACE
Do not populate resistor divider if not needed
CURRENT SENSOR
HANDCART PRESENCE
close contact when on handcart, remove before flight
12V CMOS HIGH: OK LOW: fault
Close this contact to bypass in case of no IMD present.

Parts:
C19, C27, C29, C30: 100n; C_0603_1608Metric
C23: 1u; C_0805_2012Metric
D2, D8: BAS16GW; D_SOD-123
DZ3, DZ4: MMBZ4624 4V7; D_SOT-23_ANK
J5: AIR-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J6: AIR+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
K1: KT12-1A; KT_THT
K2: UMS05-1A80-75L; G6DN-1A_DC12
Q1, Q18, Q19, Q20: TSM2306; SOT-23
Q14: BC846AW; SOT-23
Q17: DMN10H220L-7; SOT-23
R11, R13, R14, R23: 100k; R_0805_2012Metric
R15: 1M; R_0805_2012Metric
R18, R33, R60, R61, R64, R66: 10k; R_0805_2012Metric
R20: PWR163S-25-1002J 10k; pwr163
R30: 1k; R_0805_2012Metric
R31, R62, R63, R65: 22; R_0805_2012Metric
R32: 22k; R_0805_2012Metric
U11: MAX16053; SOT-23-6
U13: TS3704IPT; TSSOP-14_4.4x5mm_P0.65mm
U16: CD4044; TSSOP-16_4.4x5mm_P0.65mm
U21: CD4082; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3V3: R14.1, R60.1; also elsewhere on the board
+12V: C19.1, C29.1, C30.1, D8.1 (K), K2.2, R11.1, R13.1, R30.1, R64.1, U11.5 (VCC), U13.3 (V+), U16.5 (EN), U16.16 (Vdd), U21.14 (Vdd); also elsewhere on the board
+BATT: K1.4; also elsewhere on the board
+TS: R20.2; also elsewhere on the board
/BMS_Fault: U13.5 (+); also elsewhere on the board
/IMD_Fault: U16.12; also elsewhere on the board
/PC_Ended: R31.2; also elsewhere on the board
/SD_Status: Q1.3 (D); also elsewhere on the board
/Shutdown/1V5_REF: C27.1, R60.2, R61.1, U13.4 (-), U13.6 (-), U13.8 (-), U13.10 (-)
/Shutdown/BMS_LATCHED: R63.2, U16.9, U21.11
/Shutdown/IMD_LATCHED: R62.2, U16.10, U21.10
/Shutdown/R20_heatsink: R20.3 (back)
/Shutdown/~RESET: R11.2, U11.4 (OUT), U16.7, U16.11
/TS_ON: U13.7 (+); also elsewhere on the board
BMS_LED: Q19.3 (D); also elsewhere on the board
From_SD: K2.4, R15.1; also elsewhere on the board
From_TSMS: D2.1 (K), J5.1, J6.1, K1.1; also elsewhere on the board
GND: C19.2, C23.2, C27.2, C29.2, C30.2, D2.2 (A), DZ3.2 (A), J5.2, K1.2, Q1.2 (S), Q14.2 (E), Q17.2 (S), Q18.2 (S), Q19.2 (S), Q20.2 (S), R18.2, R33.2, R61.2, R66.1, U11.2 (GND), U13.12 (V-), U16.8 (Vss), U21.7 (Vss); also elsewhere on the board
IMD_LED: Q18.3 (D); also elsewhere on the board
INV_Enable: Q14.3 (C), R30.2; also elsewhere on the board
unnamed: C23.1, U11.6 (C_T)
unnamed: D8.2 (A), K2.1, Q20.3 (D)
unnamed: DZ3.1 (K), Q1.1 (G), R15.2
unnamed: DZ4.1 (K), J6.2, Q17.3 (D)
unnamed: DZ4.2 (A), R32.2
unnamed: K1.3, R20.1
unnamed: Q14.1 (B), R32.1
unnamed: Q17.1 (G), R31.1, R33.1
unnamed: Q18.1 (G), R62.1
unnamed: Q19.1 (G), R63.1
unnamed: Q20.1 (G), R65.1, R66.2
unnamed: R13.2, R23.1
unnamed: R18.1, R23.2, U11.3 (IN)
unnamed: R64.2, U21.12
unnamed: R65.2, U21.13
unnamed: U13.1, U21.9
unnamed: U13.2, U16.6
RESET_BUTTON: R14.2, U11.1 (EN); also elsewhere on the board
To_TSMS: K2.3; also elsewhere on the board

Notes on the sheet:
PRE-CHARGE CIRCUIT
AIR CONTROL CIRCUIT
RESET BUTTON & POR CONTROLLER
12V CMOS HIGH: OK LOW: fault
Power supply controller, gives a delay on ~RESET~ line after reset event.
3V3 uC HIGH: OK LOW: fault
Latching mechanism
Let the uC know the status of the shutdown before
Actual daisychain connection of the shutdown line
R64 can be used to manually test shutdown
CHECK: unpopulated
AIRs needs no other suppression mechanism, populate diode only if they're disconnected.
AIRs have internal suppression mechanisms that clips output to 55V, don't place outside suppression.

Parts:
C6, C26, C28: 100n; C_0603_1608Metric
C13: 10n; C_0603_1608Metric
C25: 10u; C_0805_2012Metric
C31, C32: 4.7u; C_0805_2012Metric
C33, C34: 1u; C_0805_2012Metric
J8: HV; Molex_Mega-Fit_76829-0104_2x02_P5.70mm_Vertical
J9: IMD_TS+; PinHeader_1x02_P3mm_Vertical
J10: IMD_TS-; PinHeader_1x02_P3mm_Vertical
J12: PROMINENT; Molex_Micro-Fit_3.0_43045-0412_2x02_P3.00mm_Vertical
Q16: TSM2306; SOT-23
R12, R39, R41: 10M; R_1210_3225Metric
R16, R47, R56: 100k; R_0805_2012Metric
R17, R24, R54, R55, R59: 1k; R_0805_2012Metric
R19, R21: 22; R_0805_2012Metric
R40: 71K5; R_0805_2012Metric
R42: 34K8; R_0805_2012Metric
R43, R48: 100M; R_2512_6332Metric
R44: 470; R_0805_2012Metric
R45: 10M; R_2512_6332Metric
R46: 1G; R_2512_6332Metric
R49, R50: 2.2M; R_2512_6332Metric
U3: Si8900; SOIC-16
U12: ADCMP350; Analog_KS-4
U15: LTC6259; MSOP-8_and_TSOT-23-8
U18: FODM611
U19: TPS3700; SOT-23-6
U20: TCMT1103; SOP-4_4.4x2.6mm_P1.27mm
U22: LM1117-3.3; SOT-223-3_TabPin2
U23: RFMM-0505S
U24: ROE-0505S

Connections:
+3V3: U3.10, U3.16; also elsewhere on the board
+5V: C31.1, U18.6 (VCC), U23.1 (Vin+); also elsewhere on the board
+BATT: J8.4, R39.2, R43.1; also elsewhere on the board
+TS: J8.3, J9.1, J9.2, R12.2, R41.2, R43.2, R45.1; also elsewhere on the board
-BATT: C6.2, C25.2, C26.2, C28.2, C32.2, C34.2, J8.1, R16.2, R40.2, R42.2, R48.2, R50.1, U3.8, U12.2 (GND), U15.4, U19.2 (GND), U20.3, U22.1 (GND), U23.5 (Vout-), U24.5 (Vout-)
-TS: J8.2, J10.1, J10.2, R45.2, R46.2, R48.1
/ADC_RX: R19.2; also elsewhere on the board
/ADC_TX: R21.1; also elsewhere on the board
/HV/1st_CELL_5V: C33.1, J12.1, U24.1 (Vin+)
/HV/1st_CELL_GND: C33.2, J12.3, U24.2 (Vin-)
/HV/3V3ISO: C6.1, C13.1, C32.1, R24.2, R59.1, U3.1, U22.2 (VO)
/HV/5VISO: C25.1, C26.1, C28.1, R44.1, U15.8, U19.5 (VDD), U22.3 (VI), U23.7 (Vout+)
/HV/PROMINENT+: J12.2, R17.1
/HV/PROMINENT-: J12.4, U12.3
/HV/PROM_5V: C34.1, R17.2, U12.4 (VCC), U24.7 (Vout+)
/HV/PackV: U3.4, U15.1, U15.2 (-)
/HV/TSV: U3.3, U15.6 (-), U15.7
/HV/~RST~_ADCA: C13.2, R54.1, U3.6, U20.4
/RST_ADCB: R55.1; also elsewhere on the board
GND: C31.2, Q16.2 (S), R47.2, R56.2, U3.9, U18.4 (GND), U20.2, U23.2 (Vin-); also elsewhere on the board
NRelayStat: Q16.1 (G), R47.1, U18.5 (OUT); also elsewhere on the board
unnamed: R12.1, R16.1, U12.1 (VIN)
unnamed: R19.1, U3.13
unnamed: R21.2, U3.12
unnamed: R24.1, R54.2
unnamed: R39.1, R40.1, U15.3 (+)
unnamed: R41.1, R42.1, U15.5 (+)
unnamed: R44.2, U18.1
unnamed: R46.1, R49.1, U19.3 (INA+)
unnamed: R49.2, R50.2, U19.4 (INB-)
unnamed: R55.2, R56.1, U20.1
unnamed: R59.2, U3.7
unnamed: U18.3, U19.1 (OUTA), U19.6 (OUTB)
RelayStat: Q16.3 (D); also elsewhere on the board

Notes on the sheet:
CRMA1210
CHV2512 HV Resistors
RELAY STATUS DETECTION
ISOLATED 5V VOLTAGE SOURCE
ISOLATED 3.3V VOLTAGE SOURCE
HV ADC BUFFERS
ISOLATED PACK VOLTAGE ADC WITH SPI ISOLATOR
Open drain outputs
Over and under voltage monitoring
CHECK: unpopulated
Isolated DCDC
PROMINENT INDICATOR
LTC6259 can be replaced by a LM358?

Board: 2 copper layers, 292.2 x 60.0 mm, 136 parts (23 on the bottom side), 101 nets.

## Code that names these connections

File BMS_STM32F334k8/BMS_STM32F334k8.ioc (part):

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Mcu.Name=STM32F334K(4-6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F334K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=CurrentSensor
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.GPIOParameters=PinState,GPIO_Label
PA1.GPIO_Label=PrechargeEnded
PA1.PinState=GPIO_PIN_RESET
PA1.Signal=GPIO_Output
PA10.GPIOParameters=PinState,GPIO_Label
PA10.GPIO_Label=BMS_Fault
PA10.PinState=GPIO_PIN_RESET
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_PuPd
PA11.GPIO_PuPd=GPIO_PULLUP
PA11.Mode=Master
PA11.Signal=CAN_RX
PA12.GPIOParameters=GPIO_PuPd
PA12.GPIO_PuPd=GPIO_PULLUP
PA12.Mode=Master
PA12.Signal=CAN_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=PinState,GPIO_Label
PA2.GPIO_Label=CS_ADC_PackV
PA2.PinState=GPIO_PIN_SET
PA2.Signal=GPIO_Output
PA3.GPIOParameters=PinState,GPIO_Label
PA3.GPIO_Label=CS_6820
PA3.PinState=GPIO_PIN_SET
PA3.Signal=GPIO_Output
PA4.GPIOParameters=PinState,GPIO_Label
PA4.GPIO_Label=CS_SDCard
PA4.PinState=GPIO_PIN_SET
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_PuPd,GPIO_Label
PA5.GPIO_Label=SDCard_Det
PA5.GPIO_PuPd=GPIO_PULLUP
PA5.Signal=GPIO_Input
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=ShutDownSt
PA6.Signal=GPIO_Input
PA9.GPIOParameters=PinState,GPIO_Label
PA9.GPIO_Label=TS_ON
PA9.PinState=GPIO_PIN_RESET
PA9.Signal=GPIO_Output
PB0.GPIOParameters=PinState,GPIO_Label
PB0.GPIO_Label=EEPromWc
PB0.PinState=GPIO_PIN_SET
PB0.Signal=GPIO_Output
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI1_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI1_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI1_MOSI
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=BMS_STM32F334k8

File BMS_STMF303K8/BMS_STMF303K8.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=CurrentSensor
PA0.Signal=GPIO_Analog
PA1.GPIOParameters=PinState,GPIO_Label
PA1.GPIO_Label=PrechargeEnded
PA1.PinState=GPIO_PIN_SET
PA1.Signal=GPIO_Output
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_PuPd
PA11.GPIO_PuPd=GPIO_PULLUP
PA11.Mode=Master
PA11.Signal=CAN_RX
PA12.GPIOParameters=GPIO_PuPd
PA12.GPIO_PuPd=GPIO_PULLUP
PA12.Mode=Master
PA12.Signal=CAN_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=Asynchronous
PA15.Signal=USART2_RX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=PinState,GPIO_Label
PA3.GPIO_Label=CS_6820
PA3.PinState=GPIO_PIN_SET
PA3.Signal=GPIO_Output
PA4.GPIOParameters=PinState,GPIO_Label
PA4.GPIO_Label=CS_SDCARD
PA4.PinState=GPIO_PIN_SET
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=PinState,GPIO_Label
PB0.GPIO_Label=EEPromWc
PB0.PinState=GPIO_PIN_SET
PB0.Signal=GPIO_Output
PB1.Mode=IN12-Single-Ended
PB1.Signal=ADC1_IN12
PB3.GPIOParameters=PinState
PB3.PinState=GPIO_PIN_SET
PB3.Signal=GPIO_Output
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=8000000
board=BMS_STMF303K8

## Commit log

2017-11-15 Init repo bms
2018-05-10 Added basic code
2018-05-10 Interface of the BMS
2018-05-10 split project in multiple files
2018-05-10 initial release
2018-05-10 initial release v2
2018-05-10 Implementation 108 cells monitoring
2018-05-11 first i2c EEPROM implementation
2018-05-14 initial I2C e cells temp. mon. implementation
2018-05-15 Temp. monitoring implementation
2018-05-17 temperature management
2018-05-18 All the code rewrote for stm32f334k8
2018-05-18 CAN Implementation
2018-05-21 I've indented the code
2018-05-22 revert to ltc6804
2018-05-28 split project in multi. files
2018-05-28 adc_hv
2018-05-29 ltc1865 impl.
2018-05-30 ltc1865
2018-05-31 Change image
2018-06-08 upgrade
2018-06-09 446RE upgrade rdcv, spiwriteread
2018-06-09 adcv upgrade
2018-06-15 Questo è quello giusto
2018-06-17 presentaz
2018-06-28 upload voltages
2018-06-28 Update temperature
2018-06-28 corrections
2018-06-29 update Temperature canbus
2018-06-29 Upload BMS Interface CAN MESSAGES
2018-06-30 pres
2018-07-01 Current sensor update
2018-07-01 current sensor(necessaria calibrazione),ltc1865l
2018-07-02 current sensor cal
2018-07-02 correction
2018-07-04 update 44
2018-07-07 F303
2018-07-07 f303k8
2018-07-09 9/07/18
2018-07-10 test
2018-07-10 upgrade spi
2018-07-10 copiare nuovo
2018-07-10 modified stm32f334k8
2018-07-10 temp
2018-07-10 Provvisorio, funzionante voltaggi e temperature
2018-07-10 definitivo, dio cane
2018-07-11 can init
2018-08-03 Aggiunta del codice definitivo, quello eagle
2018-08-03 Refactor of LTC68xx functions
2018-08-04 temperature fix and documentation
    Fixed temperature overflow by reducing temperature multiplier from 1000 to 100
    Added documentation for the LTC68xx libraries
    Added data age monitoring to ensure data is always up to date.
    Optimized some hspi variables
2018-08-05 Bug fixes and added persistent fault control
    Fixed some bugs, in particulare the ones related with the first voltage reading and the state not updating leading to the BMS not faulting in case of any fault.
    Added control that only if 10 consecutive reading are wrong the BMS will fault.
2018-08-06 Fixed error message transmission timing
2018-08-07 Design
2018-08-08 null
2018-08-10 can sending totV e totT, current sensor initial implementation
2018-08-15 FINAL
2018-08-16 fiin
2018-10-01 voltages
2018-10-02 organize
2018-10-08 Revert "pl"
    This reverts commit 1ea5442a49cbcff7402b05dce7ac03d08e71f6ed.
2018-10-08 revert
2018-10-08 Revert "ok"
    This reverts commit 40973bb577fbf185e6e67e75c6fb84433b5dcb39.
2018-10-08 correct
2018-11-14 Revert "correct"
    This reverts commit 48878a151bc47be09ed50d59167f1f70820f7608.
2018-11-14 Revert "Revert "pl""
    This reverts commit 7c3bd95a84a8bdca0a573d1c165222fdf48c6c73.
2018-11-14 Revert "revert"
    This reverts commit 378d9de36a5feaa56b563ba3b2416c7108df915d.
2018-11-15 functional
    This reverts commit e94dfeac313ac62606e64d04c73fc018ddecb9de.
2018-12-12 Add gitignore
2018-12-12 Add Cell struct
2018-12-12 Convert status() to structs
2018-12-12 Add common definition file
2018-12-14 Convert rdcv_voltages to structs
2018-12-14 Fix stuff
2018-12-15 Update can
2018-12-16 Rename eagle_vars
2018-12-17 Remove stm junk
2018-12-18 Implement per-cell error handling
2018-12-18 Convert rdcv_temp
2018-12-18 Include current in Pack struct
2019-01-13 Update global macros
2019-01-14 Fixes and optimizations
2019-02-17 Further parametrization of commands
2019-04-01 Add flow chart for state management
2019-04-01 Convert code to use states
2019-04-30 Make voltage and temperature functions functional
2019-05-02 Update gitignore
2019-05-02 Restructure cell array in a single variable & Add new (but flawed) error handling system & make current measuring work
2019-05-02 Remove Old_Sw
2019-05-06 Replace CELL_T with two arrays in PACK_T Add comments to document the functions, Improve error handling
2019-05-06 Update error thresholds and timeouts to meet regulations
2019-05-06 Update comments
2019-05-10 Move voltage/current/temperature in separate function. Reverse BMS_FAULT behaviour
2019-05-13 reduce ltc polling frequency
2019-05-21 Add drivers
2019-05-21 Add bms file, convert project to makefile
2019-05-21 Enable correct stm32f3 device
2019-05-21 Add vscode workspace
2019-05-21 Add launch config
2019-05-22 Fix behaviour in case of error
2019-05-22 Enhance comments
2019-05-22 Improve error management
2019-05-22 Clean unused files
2019-05-22 Update firmware
2019-05-24 Speed up voltage/temperature measurement
2019-05-24 Clean workspace file
2019-05-24 Add code formatting settings to workspace
2019-05-28 Add selectable delay in wakeup_idle
2019-06-05 Separate voltage measurement and total calculation
2019-06-05 Add emulation mode for the LTCs
2019-06-05 Improve error reporting by including the index of the cell/ltc that threw it
2019-06-18 Use right stm32 version
2019-06-18 Revert back to old firmware
2019-06-22 Enhance precharge cycle. Clean can code
2019-06-24 Clean comments and tidy code layout
2019-06-24 Fix current can message. Update precharge behaviour. Clean error file.
2019-06-28 Improve description of error functions and structures
2019-06-28 Streamline a few comments. convert pec to bool
2019-07-04 Add warning message when cell voltage is low
2019-07-04 Rework temperature reading method
2019-07-05 Fix minor stuff. Update can message for current
2019-07-07 Improve array initialization
2019-07-08 Improve pack functions
2019-07-08 Update can messages
2019-07-10 Adjust parameters
2019-07-12 Fix precharge. Bypass some useless errors
2019-07-12 Update pack struct comments
2019-07-16 CAN: add power to current message
2019-07-16 Add check for broken cells
2019-07-16 Improve charging
2019-07-30 fix hardfault caused by memcpy
    Fix CAN erratic behaviour
    Clean main.c flow
2019-08-01 Fix error triggering
2019-08-04 Add temporary bypasses
2019-08-04 Fix charging
2019-08-05 Tune cell voltage drop parameters
2019-08-29 Remove ugly workarounds.
2019-08-29 Increase error checking frequency
2019-09-17 Send warning on precharge failure
2019-09-17 Rearrange constants
2019-10-01 Initial FSM conversion
2019-10-01 Update precharge threshold to reflect EV 5.7.1 change
2019-10-09 Move code into cubemx comments
2019-10-28 Update STM32 vscode plugin config
2019-10-29 Move state machine on top of loop
2019-10-30 Small update
2020-10-28 Simplify directory structure
2020-11-01 Add initial charging code
2020-11-01 Fix can serialization
2020-11-02 Add more info on current sensor
2020-11-16 Remove workspace and useless configs
2021-02-20 core: upgrade HAL version
2021-02-20 Create new master branch
2021-02-20 Use absolute url for submodules
2021-02-21 Fix linking problems
2021-02-24 update README with project structure
2021-02-24 boilerplate additions
2021-02-24 main project files
    Files have been cleaned like for components symbols that were rescued
2021-02-24 additional files, images
2021-02-24 import of v1
    Imported the project from GG, this is the version of the last print
2021-02-26 added V2 schematic
2021-02-27 change isoadc in schematic and documents
2021-02-28 datasheet memory
2021-02-28 i2c isoadc 8901
2021-02-28 adding handcart detection
2021-03-15 Shutdown logic to use gates, changed mosfets
    Shutdown ported from new car, mosfets changed to higher VGS max
2021-03-27 chg: Add trickle charge
2021-03-27 added rele and dcdc modules
2021-03-27 ported shutdown from new car
2021-03-27 new SWD connector
2021-03-27 updated gitignore
2021-03-27 added documentation
2021-03-27 renamed connector
2021-03-28 removed erroneus R on I2c
2021-03-28 ported prominent of newcar as optional
2021-03-28 Using standard LM1117 regulator
2021-03-28 modified field for rfmm component
2021-03-28 added page settings title etc...
2021-03-28 finished footprint association
2021-03-30 Done early board
2021-04-30 board soldered
2021-05-03 added printout of the schematic V3
2021-05-05 ltc: change chip select behaviour
2021-05-05 ltc: update chip select pinout for new board
2021-05-06 ltc: fix chip select for wakeup. Still not 100% functional
2021-05-13 Fix random stuff with LTCs
2021-05-13 corrected pulldown and air+ mosfet driving
2021-05-14 update for new board
2021-05-24 DONTUSE: update stuff for new board revision
2021-06-04 Fix CAN with interrupt control
    Wait longer for precharge
2021-08-18 Fix precharge. CAN is polling but works
2021-10-05 Update current sensing for latest board revision. Implement zeroing for hall-effect sensor
2021-11-04 Not functional shit
2021-11-20 tweak params
2022-03-02 can interrupt
2022-03-04 pack: fixed temps, volts and current measuments interferences
2022-03-09 small fixes
2022-03-10 measures: fixed delays in wrong places
2022-03-11 better management of delays
2022-03-30 ltc6804: added control on not finished convertion and those values discarded
